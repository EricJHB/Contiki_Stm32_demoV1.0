# IAR project contiki.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: CMSIS; StdPeriph_Driver\inc; User; apps; contiki-3.0\core; contiki-3.0\core\sys; contiki-3.0\core\lib; contiki-3.0\cpu
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: contiki.srec
  ILINK.IlinkOutputFile: contiki.out
  ILINK.IlinkIcfFile: Linker\stm32f10x_flash
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    apps/: process-post-isr-test.c processlist.h processtest.c
  group contiki/core
    contiki-3.0/core/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group contiki/core/sys
    contiki-3.0/core/sys/: autostart.c etimer.c process.c procinit.c timer.c
  group contiki/cpu
    contiki-3.0/cpu/: clock.c debug-uart.c
  group platform/CMSIS
    CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group platform/StartUp
    StartUp/: startup_stm32f10x_md.s
  group platform/Stdperiph_Driver
    StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group platform/User
    User/: contiki-conf.h contiki-main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
